# Keil uVision project lib_lpc_chip_8xx.uvprojx, settings and files
target lib_lpc_chip_8xx (6160000::V6.16::ARMCLANG)
  device: LPC812M101JD20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_lpc_chip_8xx (library)
  c flags: Optim=5 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_M0PLUS
  c include: .\inc;D:\Keil_v5\ARM\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include;D:\Keil_v5\ARM\Packs\Keil\LPC800_DFP\1.10.1\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group inc
    ./inc/: acmp_8xx.h chip.h clock_8xx.h crc_8xx.h error_8xx.h fmc_8xx.h gpio_8xx.h i2c_common_8xx.h i2cm_8xx.h i2cs_8xx.h iap.h inmux_8xx.h iocon_8xx.h lpc_types.h mrt_8xx.h pinint_8xx.h pmu_8xx.h ring_buffer.h rom_i2c_8xx.h rom_pwr_8xx.h rom_uart_8xx.h romapi_8xx.h rtc_ut.h sct_8xx.h sct_pwm_8xx.h sys_config.h syscon_8xx.h spi_8xx.h spi_common_8xx.h spim_8xx.h spis_8xx.h stopwatch.h swm_8xx.h uart_8xx.h wkt_8xx.h wwdt_8xx.h cmsis.h irc_8xx.h
  group src
    ./src/: acmp_8xx.c chip_8xx.c clock_8xx.c crc_8xx.c gpio_8xx.c iap.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c iocon_8xx.c pinint_8xx.c pmu_8xx.c ring_buffer.c rtc_ut.c sct_8xx.c sct_pwm_8xx.c syscon_8xx.c sysinit_8xx.c spi_8xx.c spim_8xx.c spis_8xx.c stopwatch_8xx.c swm_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c irc_8xx.c

# Keil uVision project lib_2_5_digits_indicator.uvprojx, settings and files
target lib_2_5_digits_indicator (ARM-ADS)
  device: LPC812M101JD20 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_2_5_digits_indicator (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: .\inc;..\lib_lpc_chip_8xx\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group inc
    ./inc/: 2_5_digits_indicator.h
  group src
    ./src/: 2_5_digits_indicator.c

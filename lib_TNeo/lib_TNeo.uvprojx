# Keil uVision project lib_TNeo.uvprojx, settings and files
target lib_TNeo (5060020::V5.06 (build 20)::ARMCC)
  device: LPC812M101JD20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_TNeo (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: .\src;.\src\core;.\src\core\internal;.\src\arch
  asm misc: --cpreproc
  asm include: .\src;.\src\core
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group core
    ./src/core/: tn_dqueue.c tn_eventgrp.c tn_fmem.c tn_list.c tn_mutex.c tn_sem.c tn_sys.c tn_tasks.c tn_timer.c tn_timer_dyn.c tn_timer_static.c
  group arch
    ./src/arch/cortex_m/: tn_arch_cortex_m.S tn_arch_cortex_m_c.c

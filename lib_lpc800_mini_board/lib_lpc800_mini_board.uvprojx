# Keil uVision project lib_lpc800_mini_board.uvprojx, settings and files
target lib_lpc800_mini_board (6160000::V6.16::ARMCLANG)
  device: LPC810M021FN8 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IRAM(0x10000000,0x0400) IROM(0x00000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_lpc800_mini_board (library)
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_M0PLUS
  c include: .\inc;..\lib_lpc_chip_8xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x400
  group src
    ./src/: board.c
  group inc
    ./inc/: board.h board_api.h retarget.h
software components: CMSIS:CORE 5.5.0

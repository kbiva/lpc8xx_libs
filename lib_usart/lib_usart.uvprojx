# Keil uVision project lib_usart.uvprojx, settings and files
target lib_usart (6160000::V6.16::ARMCLANG)
  device: LPC812M101JD20 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_usart (library)
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_M0PLUS
  c include: .\inc;..\lib_lpc_chip_8xx\inc;..\lib_xprintf\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group inc
    ./inc/: usart.h
  group src
    ./src/: usart.c
software components: CMSIS:CORE 5.5.0

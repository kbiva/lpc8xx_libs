# Keil uVision project lib_DS18B20.uvprojx, settings and files
target lib_DS18B20 (ARM-ADS)
  device: LPC810M021FN8 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x1000) IRAM(0x10000000,0x0400) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_DS18B20 (library)
  c flags: Optim=1 OneElfS=1
  c include: .\inc;..\lib_1-Wire\inc;..\lib_lpc_chip_8xx\inc
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x400
  group inc
    ./inc/: DS18B20.h
  group src
    ./src/: DS18B20.c
